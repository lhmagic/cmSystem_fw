# Keil uVision project cmSystem.uvprojx, settings and files
target cmSystem (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: cmSystem +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ../Inc;                                                                                                            C:/Users/lhmagic/STM32Cube/Repository/STM32Cube_FW_F0_V1.9.0/Drivers/STM32F0xx_HAL_Driver/Inc;                                                                                                            C:/Users/lhmagic/STM32Cube/Repository/STM32Cube_FW_F0_V1.9.0/Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                                                                                                            C:/Users/lhmagic/STM32Cube/Repository/STM32Cube_FW_F0_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;                                                                                                            C:/Users/lhmagic/STM32Cube/Repository/STM32Cube_FW_F0_V1.9.0/Drivers/CMSIS/Device/ST/STM32F0xx/Include;                                                                                                            C:/Users/lhmagic/STM32Cube/Repository/STM32Cube_FW_F0_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/include;                                                                                                            C:/Users/lhmagic/STM32Cube/Repository/STM32Cube_FW_F0_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                                                                            C:/Users/lhmagic/STM32Cube/Repository/STM32Cube_FW_F0_V1.9.0/Drivers/CMSIS/Include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User
    ../Src/: bsp.c main.c freertos.c stm32f0xx_it.c stm32f0xx_hal_msp.c stm32f0xx_hal_timebase_TIM.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    C:/Users/lhmagic/STM32Cube/Repository/STM32Cube_FW_F0_V1.9.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Middlewares/FreeRTOS
    C:/Users/lhmagic/STM32Cube/Repository/STM32Cube_FW_F0_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    C:/Users/lhmagic/STM32Cube/Repository/STM32Cube_FW_F0_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    C:/Users/lhmagic/STM32Cube/Repository/STM32Cube_FW_F0_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.3.0
